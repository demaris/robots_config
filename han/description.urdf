Commit message: Newert configs for Han

File: han/description.urdf (robot description, URDF)
Before this commit: robot han, 12 links, 11 joints
Joints:
- joint body_camera: origin xyz=0.15 0 0.25 rpy=0 0 0 -> xyz=0.15 0 0.25 rpy=0 -0.25 0
